Commit message: Latest code

File: examples/scora/models/obstacle_course_simplified.urdf (robot description, URDF)
Before this commit: robot obstacle_course, 3 links, 1 joints
Links:
- link obstacle_1: geometry collision box size=1.414 1.414 2.0; visual box size=1.414 1.414 2.0
